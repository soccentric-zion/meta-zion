FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI:append = " file://zion-base.cfg"
